<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\LibFss.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>LIBRARY</name>
            <member>
                <project>LibFss</project>
                <configuration>Library</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
