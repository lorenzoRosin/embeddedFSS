# IAR project LibFss.ewp, settings and files
configuration Library (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\..\Code\Inc; ..\..\..\Code\Src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  group Inc
    ../../../Code/Inc/: eCU_BSTF.h eCU_BSTFPRV.h eCU_BUNSTF.h eCU_BUNSTFPRV.h eCU_CIRQ.h eCU_CRC.h eCU_CRCD.h eCU_DPK.h eCU_DUNPK.h eFSS_BLOB.h eFSS_DB.h eFSS_LOG.h eFSS_STANDARDTYPE.h eFSS_TYPE.h eFSS_UTILSHLPRV.h eFSS_UTILSLLPRV.h
  group Src
    ../../../Code/Src/: eCU_BSTF.c eCU_BUNSTF.c eCU_CIRQ.c eCU_CRC.c eCU_CRCD.c eCU_DPK.c eCU_DUNPK.c eFSS_BLOB.c eFSS_DB.c eFSS_LOG.c eFSS_UTILSHLPRV.c eFSS_UTILSLLPRV.c
