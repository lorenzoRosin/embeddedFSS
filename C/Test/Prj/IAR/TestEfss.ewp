# IAR project TestEfss.ewp, settings and files
configuration Release (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\..\Src; ..\..\..\Src\Blob\Inc; ..\..\..\Src\Core\Inc; ..\..\..\Src\Db\Inc; ..\..\..\Src\Log\Inc; ..\..\..\Src\Utils\Inc; ..\..\Src\Blob\Inc; ..\..\Src\Blob\Src; ..\..\Src\Core\Inc; ..\..\Src\Core\Src; ..\..\Src\Db\Inc; ..\..\Src\Db\Src; ..\..\Src\Log\Inc; ..\..\Src\Log\Src; ..\..\Src\Utils\Inc; ..\..\Src\Utils\Src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Src\Blob\Inc; ..\..\Src\Blob\Src; ..\..\Src\Core\Inc; ..\..\Src\Core\Src; ..\..\Src\Db\Inc; ..\..\Src\Db\Src; ..\..\Src\Log\Inc; ..\..\Src\Log\Src; ..\..\Src\Utils\Inc; ..\..\Src\Utils\Src
  OBJCOPY.OOCOutputFile: TestEfss.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkAdditionalLibs: ..\..\..\Prj\IAR\Library\Exe\LibEfss.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main.c
  group Blob/Inc
    ../../Src/Blob/Inc/: eFSS_BLOBTST.h
  group Blob/Src
    ../../Src/Blob/Src/: eFSS_BLOBTST.c
  group CoreHL/Inc
    ../../Src/CoreHL/Inc/: eFSS_BLOBCTST.h eFSS_DBCTST.h eFSS_LOGCTST.h
  group CoreHL/Src
    ../../Src/CoreHL/Src/: eFSS_BLOBCTST.c eFSS_DBCTST.c eFSS_LOGCTST.c
  group CoreLL/Inc
    ../../Src/CoreLL/Inc/: eFSS_COREHLTST.h eFSS_CORELLTST.h
  group CoreLL/Src
    ../../Src/CoreLL/Src/: eFSS_COREHLTST.c eFSS_CORELLTST.c
  group Db/Inc
    ../../Src/Db/Inc/: eFSS_DBTST.h
  group Db/Src
    ../../Src/Db/Src/: eFSS_DBTST.c
  group Log/Inc
    ../../Src/Log/Inc/: eFSS_LOGTST.h
  group Log/Src
    ../../Src/Log/Src/: eFSS_LOGTST.c
  group Utils/Inc
    ../../Src/Utils/Inc/: eFSS_UtilsTST.h
  group Utils/Src
    ../../Src/Utils/Src/: eFSS_UtilsTST.c
