<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\LibFss\LibFss.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\TestFss.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>TEST_BUILD</name>
            <member>
                <project>LibFss</project>
                <configuration>Library</configuration>
            </member>
            <member>
                <project>TestFss</project>
                <configuration>Release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
