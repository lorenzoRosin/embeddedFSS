# IAR project TestEcu.ewp, settings and files
configuration Release (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\Code\TestFunction\Inc; ..\..\Code\TestFunction\Src; ..\..\..\Code\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Code\TestFunction\Inc; ..\..\Code\TestFunction\Src
  OBJCOPY.OOCOutputFile: TestEcu.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkAdditionalLibs: ..\LibEcu\Library\Exe\LibEcu.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main.c
  group Inc
    ../../Code/TestFunction/Inc/: eCU_BSTFTST.h eCU_BUSTFTST.h eCU_CIRQTST.h eCU_CRCDTST.h eCU_CRCTST.h eCU_DPKTST.h eCU_DPKDUNPKTST.h eCU_BSTFBUNSTFTST.h eCU_DUNPKTST.h
  group Src
    ../../Code/TestFunction/Src/: eCU_BSTFTST.c eCU_BUSTFTST.c eCU_CIRQTST.c eCU_CRCDTST.c eCU_CRCTST.c eCU_DPKTST.c eCU_DPKDUNPKTST.c eCU_BSTFBUNSTFTST.c eCU_DUNPKTST.c
