# IAR project LibEfss.ewp, settings and files
configuration Library (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\Src; ..\..\Src\Blob\Inc; ..\..\Src\Blob\Src; ..\..\Src\CoreHL\Inc; ..\..\Src\CoreHL\Src; ..\..\Src\CoreLL\Inc; ..\..\Src\CoreLL\Src; ..\..\Src\Db\Inc; ..\..\Src\Db\Src; ..\..\Src\Log\Inc; ..\..\Src\Log\Src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  group (top)
    ../../Src/: eFSS_STANDARDTYPE.h eFSS_TYPE.h
  group Blob/Inc
    ../../Src/Blob/Inc/: eFSS_BLOB.h
  group Blob/Src
    ../../Src/Blob/Src/: eFSS_BLOB.c
  group CoreHL/Inc
    ../../Src/CoreHL/Inc/: eFSS_BLOBC.h eFSS_DBC.h eFSS_LOGC.h eFSS_LOGCPRV.h
  group CoreHL/Src
    ../../Src/CoreHL/Src/: eFSS_BLOBC.c eFSS_DBC.c eFSS_LOGC.c eFSS_LOGCPRV.c
  group CoreLL/Inc
    ../../Src/CoreLL/Inc/: eFSS_COREHL.h eFSS_CORELL.h eFSS_CORELLPRV.h
  group CoreLL/Src
    ../../Src/CoreLL/Src/: eFSS_COREHL.c eFSS_CORELL.c eFSS_CORELLPRV.c
  group Db/Inc
    ../../Src/Db/Inc/: eFSS_DBFL.h eFSS_DBVL.h
  group Db/Src
    ../../Src/Db/Src/: eFSS_DBFL.c eFSS_DBVL.c
  group Log/Inc
    ../../Src/Log/Inc/: eFSS_LOGFL.h eFSS_LOGVL.h
  group Log/Src
    ../../Src/Log/Src/: eFSS_LOGFL.c eFSS_LOGVL.c
